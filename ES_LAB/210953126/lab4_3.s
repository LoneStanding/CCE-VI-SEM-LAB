	AREA RESET, DATA, READONLY
	EXPORT __Vectors
__Vectors
	DCD 0X10001000
	DCD Reset_Handler
	ALIGN
	AREA MYCODE, CODE, READONLY
	ENTRY
	EXPORT Reset_Handler
Reset_Handler
	LDR R0, =HEX;
	LDR R1, [R0];
UP
	BL DIV
	CMP R1, #0;
	BNE UP
	LDR R0, =BCD;
	STR R6, [R0];
STOP
	B STOP
DIV
	MOV R3, #0;
DWN
	CMP R1, #0XA;
	BLO EXIT
	SUB R1, #0XA;
	ADD R3, #1;
	B DWN
EXIT
	LSL R1, R4;
	ORR R6, R1;
	ADD R4, #4;
	MOV R1, R3;
	BX LR
HEX DCD 0XFF
	AREA DATASEG, DATA, READWRITE
BCD DCD 0
	END